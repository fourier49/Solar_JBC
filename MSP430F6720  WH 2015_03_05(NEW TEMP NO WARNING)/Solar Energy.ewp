# IAR project Solar Energy.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F6720 MSP430F6720
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: source/inc; .
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F6720.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group App
    source/App/: communication_RS485.c DebugUART.c Interrupt.c main.c ProtocolTimer.c System_Init.c
  group Inc
    source/inc/: Bus_Raw_Protocol.h configuration.h PVInfoFrame.h ToolKit.h
  group MSP430Lib
    msp430Lib/: hal_pmm.c hal_UCS.c
  group Network
    source/Network/: Bus_Raw_Protocol.c
  group Tool_Kit
    msp430Lib/: emeter-toolkit-6720.r43
